Commit message: added proper reward and failure modes

File: fsae/resources/simpleplane.urdf (robot description, URDF)
Before this commit: robot simpleplane, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=1000 1000 0.01; visual box size=1000 1000 0.01
